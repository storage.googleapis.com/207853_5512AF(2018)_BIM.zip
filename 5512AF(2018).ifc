Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2019-05-13T16:19:50
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20181011_1645(x64) - Exporter 17.4.0.0 - Alternate UI 17.4.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Mon May 13 16:19:50 2019 * Host: Avocado-PC * Database: C:\Users\Avocado\AppData\Local\Temp\{1552ED2C-1AAB-415C-AAF3-70D0997D2658}\ifc * Database version: 5507 * Database creation date: Mon May 13 16:19:49 2019 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Mon May 13 16:19:50 2019 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Mon May 13 16:19:50 2019 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcFlowController: 5512AF Washbasin faucet, 5512AF:5512AF Washbasin faucet:340013
In: Level 1
Type - PredefinedType: FAUCET; Material: Brass
Type - Dimensions(Type) - FaucetNominalDepth: 173 mm; FaucetNominalHeight: 199 mm; FaucetNominalWidth: 58 mm; HandShowerNominalDepth: 64 mm; HandShowerNominalHeight: 338.2 mm; HandShowerNominalWidth: 45.9 mm; InletConnectionSize: 10 mm; Projection: 120 mm
Type - General(Type) - Author: Convergo AB; BIMObjectName: 5512AF; ConvergoRefNr: 0087-1905-0001-FI; ManufacterURL: http://www.oras.com/; ManufacturerName: Oras; NBSDescription: Water supply fittings for wash basin and troughs; NBSReference: 45-35-70/371; ProductInformation: n/a; Revision: n/a; Uniclass2: Pr_40_30_96_96; Uniclass2015Description: Washbasin manual water supply sets; Uniclass2015Reference: Pr_40_20_87_96; Version: 1; VersionDate: 09/04/2019
Type - Green Building Properties(Type) - Customs Code: 84818011; EAN Number: 6414150089800; EN Standard: EN 817; LVI Number: 6445400; Noise Class: I (ISO 3822); NRF Number: 4200252; RSK Number: 8325250; VVS Number: 703889204
Type - Identity Data(Type) - 2D/3D/BIM Files URL: http://static.oras.com/bim/5512AF; Catalog Drawing URL: http://static.oras.com/catdrw/5512AF; Class: Single lever, bidetta; Dimension Drawing URL: http://static.oras.com/dimdrw/5512AF; FDV Document URL: http://www.oras.com/datasheet/5512AF/en/fdv; Flow Drawing URL: http://static.oras.com/flowchart/5512AF; Group: Washbasin faucets; Long Marketing: Oras Medipro washbasin faucet with disinfection wash proof Bidetta shower set. Firm long lever offers good usability to all users and situations. Fixed spout and laminar flow. Shower hose 1.5 m, wall bracket, two pairs of quick-release couplings. Special flexible connection pipes with G3/8" nut.; Manufacturer: Oras; Market: INT;FIN;NOR;SWE;DNK;POL;RUS;EST;LTU;LVA;UKR; Model: 5512AF Washbasin faucet; Name_en: 5512AF Washbasin faucet; OmniClass Number: 23.45.55.00; OmniClass Title: Sanitary Faucets, Wastes; Package external Dimensions: 585 x 225 x 95; Package Weight: 3.045 kg; Product Code: 5512AF; Product Datasheet: https://www.oras.com/datasheet/5512AF/en; Product Family: Oras Medipro; Product Image URL: http://static.oras.com/image/5512AF; Product URL: http://static.oras.com/5512AF; Type Name: 5512AF Washbasin faucet; Usage Group: Toilets for the Disabled;Pharmacies, Opticians, Dentists;Health centers & Child welfare clinics;Hospitals
Type - Materials and Finishes(Type) - FaucetMainMaterial: Brass
Type - Mechanical(Type) - Advanced Features: DZR brass;Low lead <0.3;Waterways without nickel coating; Aerator: HONEYCOMB®; Connection Size: Ø10 mm; Diverter: Integrated diverter / automatic reset; DN Size: DN15; Flow: Laminar flow; Flow Rate At 300kPa: 0.00459091 m3/s; Hand Shower: Bidetta hand shower; Installation and Maintenance: http://static.oras.com/manual/5512AF; Installation Type: Deck mounted; Lever Handle: Long lever;Lever with H+C symbol; Max. Hot Water Supply: 80 kg/K/s3; Mounting Holes: 1 mounting hole; Number of Shower Sprays: 1 spray; Pipes: Special flexible inlet pipe(s); Pressure Loss With Flow 01ls: 180000 Pa; Shower Parts: Hand shower;Shower Hose (1500 mm);Shower holder; Shower Spray: Sensitive; Spare Parts: http://static.oras.com/sp/5512AF; Spout Type: Fixed spout
Type - Other(Type) - AccessibilityPerformance: n/a; AssetType: Fixed; Brand: Oras; Category: Health care; CodePerformance: n/a; Color: Chrome; Constituents: n/a; DurationUnit: Year; ExpectedLife: n/a; Family Name: 5512AF; Features: Single lever, bidetta; Finish: Polished; Grade: n/a; Material: Brass; ModelNumber: n/a; ModelReference: 5512AF; Name: 5512AF Washbasin faucet; ReplacementCost: n/a; Shape: Sculptured; Size: Faucet:58x173x199 mm / Hand shower: 46x64x338 mm; SustainabilityPerformance: n/a; WarrantyDescription: http://warranty.oras.com; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: Year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Type - Text(Type) - Comfort Sales Arguments: Quick and easy to clean.; Health Sales Arguments: Brass in contact with drinking water contains less than 0.3% lead.;Surfaces in contact with drinking water do not have a nickel coating.
Pset_ManufacturerTypeInformation - ModelReference: 5512AF; Manufacturer: Oras
Pset_DistributionFlowElementCommon - Reference: 5512AF Washbasin faucet
Constraints - DistanceX-Axis: 100 mm; DistanceY-Axis: 100 mm; FaucetDefaultElevation: 900 mm; HandShowerDefaultElevation: 900 mm; HandshowerVisibility: yes; Host: Level : Level 1; Level: Level: Level 1; Offset: 0 mm
Dimensions - Area: 0.0972485 m2; Volume: 0.00299714 m3
Identity Data - Mark: 1
Mechanical - System Classification: Domestic Hot Water,Domestic Cold Water
Other - AssetIdentifier: n/a; Barcode: n/a; Category: Plumbing Fixtures; Family: 5512AF: 5512AF Washbasin faucet; Family and Type: 5512AF: 5512AF Washbasin faucet; InstallationDate: n/a; SerialNumber: n/a; TagNumber: n/a; Type: 5512AF: 5512AF Washbasin faucet; Type Id: 5512AF: 5512AF Washbasin faucet; WarrantyStartDate: n/a
Phasing - Phase Created: New Construction
